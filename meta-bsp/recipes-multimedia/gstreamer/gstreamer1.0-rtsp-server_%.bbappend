# Disable introspection to fix [GstPlayer-1.0.gir] Error
EXTRA_OECONF_append_imx = " \
    --disable-introspection \
"

