FILESEXTRAPATHS_prepend_imx := "${THISDIR}/${BPN}:"

SRC_URI_append_imx = " file://0001-add-support-for-RSA-public-and-private-key-operation.patch "
