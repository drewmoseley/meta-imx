# Update 10-imx.rules 
FILESEXTRAPATHS_prepend_imx := "${THISDIR}/${PN}:"

