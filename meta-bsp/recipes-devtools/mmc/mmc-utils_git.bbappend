# Update the revision "use MMC_IOC_MULTI_CMD for RPMB access"

SRCREV_imx = "aef913e31b659462fe6b9320d241676cba97f67b"

SRC_URI_remove_imx = "file://0001-lsmmc-replace-strncpy-with-memmove-on-overlapping-me.patch"
