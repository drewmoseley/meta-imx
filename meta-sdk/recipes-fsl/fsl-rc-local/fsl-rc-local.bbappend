#Provide our own rc.local file
FILESEXTRAPATHS_prepend_imx := "${THISDIR}/files:"
