# Replace linux-mfgtool with virtual/kernel

DEPENDS_remove_imx = "linux-mfgtool"
DEPENDS_append_imx = " virtual/kernel"
