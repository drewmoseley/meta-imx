RDEPENDS_${PN}-test_imx = "python3-core"
