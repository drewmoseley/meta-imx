
RDEPENDS_${PN}_remove_imx = "qtquick1-dev \
    qtquick1-mkspecs \
    qtquick1-plugins \
    qtquick1-qmlplugins \
    qttranslations-qtquick1 \
    qtwebkit-dev \
    qtwebkit-mkspecs \
    qtwebkit-qmlplugins \
"

RDEPENDS_${PN}_append_imx = " \
    qtdeclarative-tools \
    qtquick3d \
    qtquick3d-dev \
    qtquick3d-examples \
"
