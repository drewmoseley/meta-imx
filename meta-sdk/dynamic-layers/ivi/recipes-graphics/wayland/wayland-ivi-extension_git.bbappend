FILESEXTRAPATHS_prepend_imx := "${THISDIR}/${BPN}:"

SRC_URI_append_imx = " file://0001-ivi-input-controller-Update-header-path-for-weston-7.patch "
