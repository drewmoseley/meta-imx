RDEPENDS_${PN}_remove_imx = "common-api-c++-someip vsomeip"
