
RDEPENDS_${PN}_append_imx = " weston-init"
