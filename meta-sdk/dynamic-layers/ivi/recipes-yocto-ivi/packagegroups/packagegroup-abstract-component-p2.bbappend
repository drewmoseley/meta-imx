
RDEPENDS_${PN}_remove_imx = "audiomanagerplugins"
