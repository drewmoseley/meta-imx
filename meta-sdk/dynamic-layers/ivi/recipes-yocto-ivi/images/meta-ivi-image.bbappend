IMAGE_FEATURES_append_imx = " nfs-server ssh-server-openssh tools-debug "
IMAGE_INSTALL_append_imx = " packagegroup-fsl-tools-testapps packagegroup-fsl-tools-gpu "
