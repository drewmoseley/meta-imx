FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI_append_imx = " file://0001-audiomanager-Workaround-to-pass-the-configure-error.patch"
