# Temp fix build with GCC 9
CPPFLAGS_append_imx = " -Wno-error=stringop-truncation "
