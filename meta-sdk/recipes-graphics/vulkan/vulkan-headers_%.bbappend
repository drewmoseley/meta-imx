
COMPATIBLE_MACHINE_imx = "(mx8)"
COMPATIBLE_MACHINE_mx8mm = "(^$)"
