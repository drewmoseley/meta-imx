DEPENDS_remove_imx = "vulkan"
DEPENDS_append_imx = " vulkan-headers vulkan-loader"
